DESCRIPTION = "CRC32C for Arm"
LICENSE = "CLOSED"

SRC_URI = "file://crc32c/"

S = "${WORKDIR}/crc32c"

inherit setuptools3

