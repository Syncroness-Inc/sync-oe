FILESEXTRAPATHS_prepend := "${THISDIR}/lxdm:"

SRC_URI += " \
	file://0001-disable-cursor.patch \
"
