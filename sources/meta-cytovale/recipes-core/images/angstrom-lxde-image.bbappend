IMAGE_INSTALL += " packagegroup-cytovale-cym packagegroup-cytovale-cym-debug "
