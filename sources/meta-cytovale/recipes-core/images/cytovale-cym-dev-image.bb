DESCRIPTION = "Cytovale Cytometry Module Development Image."

IMAGE_INSTALL = "packagegroup-cytovale-cym packagegroup-sync-dev"

IMAGE_LINGUAS = " "

LICENSE = "MIT"

inherit core-image
