DESCRIPTION = "Cytovale Cytometry Module Image."

IMAGE_INSTALL= "packagegroup-cytovale-cym"

IMAGE_LINGUAS = " "

LICENSE = "MIT"

inherit core-image-minimal
