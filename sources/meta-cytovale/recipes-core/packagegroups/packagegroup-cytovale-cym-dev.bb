SUMMARY = "Packages used during CYM development"
PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = " git "
