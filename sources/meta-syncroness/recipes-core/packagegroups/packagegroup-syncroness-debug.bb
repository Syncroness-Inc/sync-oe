SUMMARY = "Packages used by syncroness developers"
PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = " git openssh "
